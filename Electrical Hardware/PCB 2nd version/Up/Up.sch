File: Electrical Hardware/PCB 2nd version/Up/Up.sch (EAGLE design)
At the start: 44 parts

Commit message: update PCB 3rd v
Other:
- moved on the sheet: JP1, JP2, SWD, SWD1, U$11, U$4, U$5, U$8
